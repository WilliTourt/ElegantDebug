# Keil uVision project ElegantDebug8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: app +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Src-C
  asm include: ..\..\Src-C
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../../Src-C/: ElegantDebug.c
